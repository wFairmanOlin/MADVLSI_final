v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -430 -1300 -400 -1300 { lab=GND}
N -430 -1330 -430 -1300 { lab=GND}
N -400 -1300 -400 -1280 { lab=GND}
N -1250 -1440 -1250 -1410 { lab=GND}
N -1150 -1440 -1150 -1410 { lab=GND}
N -1250 -1410 -1250 -1380 { lab=GND}
N -1200 -1440 -1200 -1410 { lab=GND}
N -1100 -1440 -1100 -1410 { lab=GND}
N -1000 -1440 -1000 -1410 { lab=GND}
N -1050 -1440 -1050 -1410 { lab=GND}
N -950 -1440 -950 -1410 { lab=GND}
N -900 -1440 -900 -1410 { lab=GND}
N -800 -1440 -800 -1410 { lab=GND}
N -850 -1440 -850 -1410 { lab=GND}
N -1250 -1410 -770 -1410 { lab=GND}
N -1220 -1470 -770 -1470 { lab=#net1}
N -1250 -1330 -1250 -1300 { lab=GND}
N -1150 -1330 -1150 -1300 { lab=GND}
N -1250 -1300 -1250 -1270 { lab=GND}
N -1200 -1330 -1200 -1300 { lab=GND}
N -1100 -1330 -1100 -1300 { lab=GND}
N -1000 -1330 -1000 -1300 { lab=GND}
N -1050 -1330 -1050 -1300 { lab=GND}
N -950 -1330 -950 -1300 { lab=GND}
N -900 -1330 -900 -1300 { lab=GND}
N -800 -1330 -800 -1300 { lab=GND}
N -850 -1330 -850 -1300 { lab=GND}
N -1250 -1300 -770 -1300 { lab=GND}
N -1220 -1360 -770 -1360 { lab=#net1}
N -770 -1470 -690 -1470 { lab=#net1}
N -770 -1360 -690 -1360 { lab=#net1}
N -690 -1470 -690 -1360 { lab=#net1}
N -690 -1360 -690 -1250 { lab=#net1}
N -1250 -1220 -1250 -1190 { lab=GND}
N -1150 -1220 -1150 -1190 { lab=GND}
N -1250 -1190 -1250 -1160 { lab=GND}
N -1200 -1220 -1200 -1190 { lab=GND}
N -1100 -1220 -1100 -1190 { lab=GND}
N -1000 -1220 -1000 -1190 { lab=GND}
N -1050 -1220 -1050 -1190 { lab=GND}
N -950 -1220 -950 -1190 { lab=GND}
N -900 -1220 -900 -1190 { lab=GND}
N -800 -1220 -800 -1190 { lab=GND}
N -850 -1220 -850 -1190 { lab=GND}
N -1250 -1190 -770 -1190 { lab=GND}
N -1220 -1250 -770 -1250 { lab=#net1}
N -770 -1250 -690 -1250 { lab=#net1}
N -690 -1250 -690 -1140 { lab=#net1}
N -1250 -1110 -1250 -1080 { lab=GND}
N -1150 -1110 -1150 -1080 { lab=GND}
N -1250 -1080 -1250 -1050 { lab=GND}
N -1200 -1110 -1200 -1080 { lab=GND}
N -1100 -1110 -1100 -1080 { lab=GND}
N -1000 -1110 -1000 -1080 { lab=GND}
N -1050 -1110 -1050 -1080 { lab=GND}
N -950 -1110 -950 -1080 { lab=GND}
N -900 -1110 -900 -1080 { lab=GND}
N -800 -1110 -800 -1080 { lab=GND}
N -850 -1110 -850 -1080 { lab=GND}
N -1250 -1080 -770 -1080 { lab=GND}
N -1220 -1140 -770 -1140 { lab=#net1}
N -770 -1140 -690 -1140 { lab=#net1}
N -690 -1140 -690 -1030 { lab=#net1}
N -1250 -1000 -1250 -970 { lab=GND}
N -1150 -1000 -1150 -970 { lab=GND}
N -1250 -970 -1250 -940 { lab=GND}
N -1200 -1000 -1200 -970 { lab=GND}
N -1100 -1000 -1100 -970 { lab=GND}
N -1000 -1000 -1000 -970 { lab=GND}
N -1050 -1000 -1050 -970 { lab=GND}
N -950 -1000 -950 -970 { lab=GND}
N -900 -1000 -900 -970 { lab=GND}
N -800 -1000 -800 -970 { lab=GND}
N -850 -1000 -850 -970 { lab=GND}
N -1250 -970 -770 -970 { lab=GND}
N -1220 -1030 -770 -1030 { lab=#net1}
N -770 -1030 -690 -1030 { lab=#net1}
N -690 -1470 -670 -1470 { lab=#net1}
N -430 -1560 -430 -1530 { lab=#net2}
N -430 -1530 -430 -1500 { lab=#net2}
N -570 -1560 -570 -1530 { lab=#net2}
N -570 -1530 -570 -1500 { lab=#net2}
N -540 -1590 -540 -1470 { lab=VDD}
N -460 -1590 -460 -1470 { lab=VDD}
N -540 -1590 -460 -1590 { lab=VDD}
N -500 -1710 -500 -1590 { lab=VDD}
N -400 -1590 -400 -1470 { lab=#net3}
N -600 -1590 -600 -1550 { lab=#net4}
N -600 -1550 -600 -1470 { lab=#net4}
N -400 -1470 -400 -1440 { lab=#net3}
N -600 -1470 -600 -1440 { lab=#net4}
N -400 -1380 -400 -1360 { lab=#net5}
N -500 -1510 -500 -1370 { lab=#net5}
N -710 -1510 -500 -1510 { lab=#net5}
N -910 -1510 -710 -1510 { lab=#net5}
N -1250 -1050 -1250 -1000 { lab=GND}
N -1250 -1160 -1250 -1110 { lab=GND}
N -1250 -1380 -1250 -1330 { lab=GND}
N -1250 -1270 -1250 -1220 { lab=GND}
N -500 -1370 -400 -1370 { lab=#net5}
N -330 -1550 -330 -1450 { lab=#net3}
N -330 -1550 -290 -1550 { lab=#net3}
N -400 -1450 -330 -1450 { lab=#net3}
N -290 -1550 -170 -1550 { lab=#net3}
N -170 -1510 -170 -1440 { lab=vout10}
N -170 -1440 -30 -1440 { lab=vout10}
N -30 -1530 -30 -1440 { lab=vout10}
N -30 -1530 30 -1530 { lab=vout10}
N -30 -1440 -30 -1360 { lab=vout10}
N -30 -1300 -30 -1220 { lab=#net6}
N -30 -1160 -30 -1100 { lab=GND}
N 50 -1220 50 -1150 { lab=#net7}
N 50 -1150 190 -1150 { lab=#net7}
N 190 -1240 190 -1150 { lab=#net7}
N 190 -1240 250 -1240 { lab=#net7}
N -30 -1260 50 -1260 { lab=#net6}
N 190 -1090 190 -1040 { lab=#net8}
N 290 -1020 290 -950 { lab=vout4}
N 290 -950 430 -950 { lab=vout4}
N 430 -1040 430 -950 { lab=vout4}
N 190 -1060 290 -1060 { lab=#net8}
N 430 -1040 500 -1040 { lab=vout4}
N 250 -1200 250 -1130 { lab=vout8}
N 250 -1130 390 -1130 { lab=vout8}
N 390 -1220 390 -1130 { lab=vout8}
N 390 -1220 450 -1220 { lab=vout8}
N -670 -1470 -660 -1470 { lab=#net1}
N -660 -1470 -660 -1440 { lab=#net1}
N -600 -1380 -600 -1350 { lab=#net9}
N -660 -1380 -660 -1350 { lab=#net10}
N -640 -1410 -620 -1410 { lab=GND}
N -630 -1370 -620 -1410 { lab=GND}
N -660 -1370 -650 -1370 { lab=#net10}
N -650 -1550 -650 -1370 { lab=#net10}
N -570 -1530 -430 -1530 { lab=#net2}
N -770 -1530 -570 -1530 { lab=#net2}
N -910 -1550 -650 -1550 { lab=#net10}
N -630 -1440 -630 -1410 { lab=GND}
N -380 -1410 -370 -1410 { lab=GND}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1220 -1440 0 0 {name=XQ108
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -400 -1330 0 0 {name=XQ109
model=W0p68L0p68}
C {madvlsi/gnd.sym} -400 -1280 0 0 {name=l48 lab=GND}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1120 -1440 0 0 {name=XQ110
model=W0p68L0p68}
C {madvlsi/gnd.sym} -1250 -940 0 0 {name=l52 lab=GND}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1170 -1440 0 0 {name=XQ111
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1070 -1440 0 0 {name=XQ112
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -970 -1440 0 0 {name=XQ113
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1020 -1440 0 0 {name=XQ114
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -920 -1440 0 0 {name=XQ115
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -870 -1440 0 0 {name=XQ116
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -770 -1440 0 0 {name=XQ117
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -820 -1440 0 0 {name=XQ118
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1220 -1330 0 0 {name=XQ119
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1120 -1330 0 0 {name=XQ120
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1170 -1330 0 0 {name=XQ121
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1070 -1330 0 0 {name=XQ122
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -970 -1330 0 0 {name=XQ123
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1020 -1330 0 0 {name=XQ124
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -920 -1330 0 0 {name=XQ125
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -870 -1330 0 0 {name=XQ126
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -770 -1330 0 0 {name=XQ127
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -820 -1330 0 0 {name=XQ128
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1220 -1220 0 0 {name=XQ129
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1120 -1220 0 0 {name=XQ130
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1170 -1220 0 0 {name=XQ131
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1070 -1220 0 0 {name=XQ132
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -970 -1220 0 0 {name=XQ133
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1020 -1220 0 0 {name=XQ134
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -920 -1220 0 0 {name=XQ135
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -870 -1220 0 0 {name=XQ136
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -770 -1220 0 0 {name=XQ137
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -820 -1220 0 0 {name=XQ138
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1220 -1110 0 0 {name=XQ139
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1120 -1110 0 0 {name=XQ140
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1170 -1110 0 0 {name=XQ141
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1070 -1110 0 0 {name=XQ142
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -970 -1110 0 0 {name=XQ143
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1020 -1110 0 0 {name=XQ144
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -920 -1110 0 0 {name=XQ145
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -870 -1110 0 0 {name=XQ146
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -770 -1110 0 0 {name=XQ147
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -820 -1110 0 0 {name=XQ148
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1220 -1000 0 0 {name=XQ149
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1120 -1000 0 0 {name=XQ150
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1170 -1000 0 0 {name=XQ151
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1070 -1000 0 0 {name=XQ152
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -970 -1000 0 0 {name=XQ153
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -1020 -1000 0 0 {name=XQ154
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -920 -1000 0 0 {name=XQ155
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -870 -1000 0 0 {name=XQ156
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -770 -1000 0 0 {name=XQ157
model=W0p68L0p68}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/models/sky130_fd_pr__pnp_05v0.sym} -820 -1000 0 0 {name=XQ158
model=W0p68L0p68}
C {madvlsi/pmos3.sym} -570 -1590 3 0 {name=M1
L=0.15
W=10
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -570 -1470 1 0 {name=M2
L=0.15
W=10
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -430 -1470 1 0 {name=M3
L=0.15
W=10
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -430 -1590 3 0 {name=M4
L=0.15
W=10
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/opamp_square.sym} -790 -1530 0 0 {name=X1}
C {madvlsi/vdd.sym} -500 -1710 0 0 {name=l1 lab=VDD}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/opamp.sym} -50 -1530 0 0 {name=X2}
C {madvlsi/gnd.sym} -30 -1100 0 0 {name=l5 lab=GND}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/opamp_square.sym} 170 -1240 0 0 {name=X3}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/opamp.sym} 410 -1040 0 0 {name=X4}
C {madvlsi/gnd.sym} 190 -980 0 0 {name=l7 lab=GND}
C {/home/madvlsi/Desktop/MADVLSI_final/schematics/opamp_square.sym} 370 -1220 0 0 {name=X5}
C {sky130_fd_pr/res_high_po.sym} -660 -1410 2 0 {name=R8
W=.7
L=4.25
model=res_high_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po.sym} -30 -1190 0 0 {name=R9
W=.7
L=14
model=res_high_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po.sym} -600 -1410 0 0 {name=R3
W=.7
L=4.25
model=res_high_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po.sym} -630 -1350 1 0 {name=R4
W=.7
L=4.25
model=res_high_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} -630 -1440 2 0 {name=l9 lab=GND}
C {sky130_fd_pr/res_high_po.sym} -400 -1410 2 0 {name=R10
W=.7
L=4.25
model=res_high_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} -370 -1410 3 0 {name=l10 lab=GND}
C {sky130_fd_pr/res_high_po.sym} -30 -1330 0 0 {name=R1
W=.7
L=4.25
model=res_high_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po.sym} 190 -1120 0 0 {name=R2
W=.7
L=14
model=res_high_po
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po.sym} 190 -1010 0 0 {name=R5
W=.7
L=14
model=res_high_po
spiceprefix=X
mult=1}
C {madvlsi/gnd.sym} -50 -1190 1 0 {name=l11 lab=GND}
C {madvlsi/gnd.sym} 170 -1120 1 0 {name=l12 lab=GND}
C {madvlsi/gnd.sym} 170 -1010 1 0 {name=l13 lab=GND}
C {madvlsi/gnd.sym} -50 -1330 1 0 {name=l14 lab=GND}
C {devices/opin.sym} 30 -1530 0 0 {name=p1 lab=vout10}
C {devices/opin.sym} 450 -1220 0 0 {name=p2 lab=vout8}
C {devices/opin.sym} 500 -1040 0 0 {name=p3 lab=vout4}
